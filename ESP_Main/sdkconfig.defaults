## ESP_Main/sdkconfig.defaults
```kconfig
#
# FREERTOS
#
CONFIG_FREERTOS_HZ=1000
# end of FREERTOS
# end of Component config
```
